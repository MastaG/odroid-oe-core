DEPENDS:append = " libxshmfence libxkbcommon"
